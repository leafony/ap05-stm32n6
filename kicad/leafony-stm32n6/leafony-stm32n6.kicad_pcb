# Repository leafony/ap05-stm32n6

File README.md:

# AP05 STM32N6

LeafonyのMCUリーフ「AP05 STM32N6」のハードウェア設計リポジトリです。KiCadの回路図・基板データ、部品ライブラリ、製造用データを収録しています。

AP05は、STMicroelectronicsのSTM32N6シリーズを採用し、Arm Cortex-M55による画像処理やエッジAIの評価に利用するリーフです。製品概要は[Leafony公式ドキュメント](https://docs.leafony.com/leaf/processor/ap05/)を参照してください。

## 主な用途

- カメラを使った画像処理・エッジAIアプリケーションの試作
- STM32N6向けファームウェアの開発・検証
- Leafony Busを介した他のリーフとの接続・評価

## ハードウェア構成

以下は、本リポジトリの回路図・基板データに記載されている構成です。

| 項目 | 内容 |
| --- | --- |
| MCU | STM32N657L0H3Q（STMicroelectronics） |
| CPU | Arm Cortex-M55 |
| 外部Flash | MX25UM51245GXDI00-TR |
| 外部PSRAM | APS256XXN-OBR-BG |
| 接続 | Leafony Bus、USB Type-C、カメラコネクタ、デバッグ用コネクタ |
| 基板 | 6層、板厚0.8 mm |
| 設計ツール | KiCad 9.0 |

ピン接続や電源回路の詳細は、[回路図](kicad/leafony-stm32n6/exported/leafony-stm32n6_schematics.pdf)を参照してください。

## 基板イメージ

設計データから出力した3D表示です。

| 表面 | 裏面 |
| --- | --- |
|  |  |

## 設計資料

| 資料 | ファイル |
| --- | --- |
| KiCadプロジェクト | [leafony-stm32n6.kicad_pro](kicad/leafony-stm32n6/leafony-stm32n6.kicad_pro) |
| 回路図 | [PDF](kicad/leafony-stm32n6/exported/leafony-stm32n6_schematics.pdf) / [KiCad](kicad/leafony-stm32n6/leafony-stm32n6.kicad_sch) |
| 基板レイアウト | [PDF](kicad/leafony-stm32n6/exported/leafony-stm32n6_layout.pdf) / [KiCad](kicad/leafony-stm32n6/leafony-stm32n6.kicad_pcb) |
| 部品表（BOM） | [Excel](kicad/leafony-stm32n6/exported/leafony-stm32n6_BOM.xlsx) |
| 基板3Dモデル | [STEP](kicad/leafony-stm32n6/exported/leafony-stm32n6.step) |
| 製造用データ | [Gerber・ドリル・部品位置データ](kicad/leafony-stm32n6/exported/Gerber/) |

## ディレクトリ構成

```text
kicad/leafony-stm32n6/
├── leafony-stm32n6.kicad_pro   # KiCadプロジェクト
├── leafony-stm32n6.kicad_sch   # トップ階層の回路図
├── leafony-stm32n6.kicad_pcb   # 基板レイアウト
├── *.kicad_sch                # MCU、電源、メモリ、USBなどの階層回路図
├── sym-lib-table              # プロジェクト用シンボルライブラリ設定
├── fp-lib-table               # プロジェクト用フットプリントライブラリ設定
├── lib/
│   ├── Leafony.kicad_sym      # Leafony用シンボル
│   ├── Leafony.pretty/        # Leafony用フットプリント
│   └── 3dmodels/              # 部品の3Dモデル
├── assets/                   # 設計関連の画像
└── exported/                 # 回路図PDF、BOM、STEP、基板画像など
    └── Gerber/               # Gerber、ドリル、部品位置データ
```

## KiCadで開く

1. KiCad 9.0と標準ライブラリを用意します。3D表示を使用する場合は標準3Dモデルもインストールしてください。
2. このリポジトリをcloneするか、ZIPでダウンロードして展開します。
3. `kicad/leafony-stm32n6/leafony-stm32n6.kicad_pro` をKiCadで開きます。
4. プロジェクトマネージャーから回路図エディターまたはPCBエディターを起動します。

Leafony用のシンボルとフットプリントは、プロジェクト内の `sym-lib-table` と `fp-lib-table` から `${KIPRJMOD}/lib/` を参照します。フォルダー構成を保ったまま開いてください。基板の標準3Dモデルは `KICAD9_3DMODEL_DIR` を参照しています。

## ファームウェア開発

公式ドキュメントでは、STM32N6向けの開発環境としてSTM32CubeIDEと[STM32CubeN6](https://github.com/STMicroelectronics/STM32CubeN6)が案内されています。本リポジトリにはファームウェアを収録していません。

## 関連リンク

- [AP05 STM32N6 — Leafony公式ドキュメント](https://docs.leafony.com/leaf/processor/ap05/)
- [STM32N6シリーズ — STMicroelectronics](https://www.st.com/en/microcontrollers-microprocessors/stm32n6-series.html)
- [STM32N6シリーズの技術資料](https://www.st.com/en/microcontrollers-microprocessors/stm32n6-series/documentation.html)
- [STM32CubeN6 — 公式GitHubリポジトリ](https://github.com/STMicroelectronics/STM32CubeN6)

## KiCad design kicad/leafony-stm32n6/leafony-stm32n6.kicad_pcb

Parts:
H1, H2, H3, H4: MountingHole_Pad; MountingHole_2.2mm_M2_Pad

Connections:
GND: H1.1, H2.1, H3.1, H4.1; also elsewhere on the board

Parts:
C46, C47, C48: 100nF(M) 16V X7R; C_0201_0603Metric
C49, C50, C51: 4.7uF(M) 16V X5R; C_0603_1608Metric
D4: BAT60JFILM; CR_60JFILM_STM
R59, R60, R62: 10k(J); R_0402_1005Metric
R61: 0R; R_0402_1005Metric
R63: 0R 1/4W; R_0603_1608Metric
U4: MX25UM51245GXDI00-TR; BGA24C100P5X5_800X600X120

Connections:
GND: C46.1, C47.1, C48.1, C49.1, C50.1, C51.1, U4.B3 (GND), U4.C1 (VSSQ_1), U4.E5 (VSSQ_2); also elsewhere on the board
NRST: D4.1; also elsewhere on the board
unnamed: R61.1, U4.C2 (~CS)
unnamed: R62.1, U4.A5 (~ECS)
unnamed: D4.2, R59.2, U4.A4 (~RESET)
OCTOSPI_CLK: U4.B2 (SCLK); also elsewhere on the board
OCTOSPI_DSQ: U4.C3 (DQS); also elsewhere on the board
OCTOSPI_IO0: U4.D3 (SIO0); also elsewhere on the board
OCTOSPI_IO1: U4.D2 (SIO1); also elsewhere on the board
OCTOSPI_IO2: U4.C4 (SIO2); also elsewhere on the board
OCTOSPI_IO3: U4.D4 (SIO3); also elsewhere on the board
OCTOSPI_IO4: U4.D5 (SIO4); also elsewhere on the board
OCTOSPI_IO5: U4.E3 (SIO5); also elsewhere on the board
OCTOSPI_IO6: U4.E2 (SIO6); also elsewhere on the board
OCTOSPI_IO7: U4.E1 (SIO7); also elsewhere on the board
OCTOSPI_NCS: R60.2, R61.2; also elsewhere on the board
VDDA1V8: R63.1; also elsewhere on the board
VDD_OCTOSPI_M: C46.2, C47.2, C48.2, C49.2, C50.2, C51.2, R59.1, R60.1, R62.2, R63.2, U4.B4 (VCC), U4.D1 (VCCQ_1), U4.E4 (VCCQ_2)

Notes on the sheet:
100 nF/4.7μF decoupling for each pair B4/B3 - E4/E5- C1/D1

Parts:
C39: 10nF(M) 50V X7R; C_0402_1005Metric
C40: 100nF(M) 16V X7R; C_0201_0603Metric
C41: 0.47uF(M) 6.3V X5R; C_0402_1005Metric
D2: SML-A12U8TT86; LED_SML-A12_ROM
D3: 1SS387; D_SOD-523
J1: BM06B-SRSS-TB; JST_SH_BM06B-SRSS-TB_1x06-1MP_P1.00mm_Vertical
J2: FTSH-107-01-L-DV-K-A; SAMTEC_FTSH-107-01-L-DV-K-A; PARTREV H
Q1: RE1C002UNTCL; DIO_RB558WMF_ROM
R50: 1k(J); R_0402_1005Metric
R51, R54: 10k(J); R_0402_1005Metric
R52, R55: 100k(J); R_0402_1005Metric
R53: 100R(J); R_0402_1005Metric
R56: 0R; R_0402_1005Metric
SW1: EVQ-P7B01P
SW2: CUS-12TB; CUS-12TB_NDC
U2: TS3A4751RUCR; RUC14

Connections:
+5V: J1.1; also elsewhere on the board
BOOT1: Q1.1, R50.1, R51.2, SW2.2, U2.6 (IN3), U2.12 (IN4); also elsewhere on the board
D0: J1.3; also elsewhere on the board
D1: J1.4; also elsewhere on the board
D9: U2.2 (COM1); also elsewhere on the board
D9_MCU: R53.1, U2.1 (NO1); also elsewhere on the board
GND: C39.1, C40.1, D2.1 (K), J1.6, J1.MP (SHIELD), J2.05, J2.07, J2.11, Q1.2, R51.1, SW1.2, SW1.3, SW2.SH, U2.7 (GND), U2.8 (NO3), U2.10 (COM4); also elsewhere on the board
NRST: C39.2, D3.2 (A), J2.12, R56.2, SW1.1, SW1.4; also elsewhere on the board
unnamed: C41.2, R56.1
unnamed: D2.2 (A), R50.2
unnamed: C41.1, R55.2, U2.9 (COM3)
unnamed: Q1.3, R54.2, U2.5 (IN2), U2.13 (IN1)
unnamed: R53.2, U2.11 (NO4)
SWCLK: J2.06; also elsewhere on the board
SWDIO: J2.04; also elsewhere on the board
SWO: J2.08; also elsewhere on the board
TEST_N: J1.5, R52.1; also elsewhere on the board
VCP_RX: J2.13; also elsewhere on the board
VCP_TX: J2.14; also elsewhere on the board
VDD3V3: J1.2, R52.2; also elsewhere on the board
VDDIO: C40.2, D3.1 (K), J2.03, R54.1, R55.1, SW2.3, U2.14 (V+); also elsewhere on the board

Notes on the sheet:
<-Tx(MCU)
->Rx(MCU)

Parts:
C5, C14, C17, C18, C19, C20, C21, C29, C31: 1uF(M) 6.3V X5R; C_0201_0603Metric
C6, C11, C15, C16, C22, C23, C24, C25, C26, C27, C28, C30, C32, C34, C36, C37, C38, C71, C72, C73, C74: 100nF(M) 16V X7R; C_0201_0603Metric
C7, C8, C9, C10: 22uF(M) 6.3V X5R; C_0603_1608Metric
C12: 4.7uF(M) 10V X5R; C_0402_1005Metric
C13: 2.2nF(M) 50V X7R; C_0402_1005Metric
C33, C35: 10uF(M) 10V X7R; C_0603_1608Metric
FB1: MPZ1005S300CT000; Fuse_0402_1005Metric
L1: 1.0uH; IND_DFE201610E_MUR
L2: 18R@100MHz; L_0603_1608Metric
L3: 2.2nH; L_0603_1608Metric
R45: 0R 1/4W; R_0603_1608Metric
R46: 0R 1/4W; R_0603_1608Metric; not fitted
R47: 0R; R_0402_1005Metric; not fitted
R48: 0R; R_0402_1005Metric
R49: 2R(F); R_0402_1005Metric
U1: STM32N657L0H3Q; VFBGA223_10X10_STM

Connections:
A3: R47.2; also elsewhere on the board
AREF: R46.2; also elsewhere on the board
GND: C5.1, C6.1, C7.2, C8.2, C9.2, C10.2, C11.1, C12.1, C13.1, C14.2, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, C30.1, C31.1, C32.1, C33.2, C34.1, C35.2, C36.1, C37.1, C38.1, C71.1, C72.1, C73.1, C74.1, R48.2, U1.A19 (VSS), U1.F12 (VSS), U1.G6 (VSSAON), U1.H2 (VSSAPMU), U1.H14 (VSS), U1.J1 (VSSSMPS), U1.J2 (VSSSMPS), U1.J3 (VSSSMPS), U1.J4 (VSSSMPS), U1.J5 (VSSSMPS), U1.N16 (VSS), U1.P8 (VSS), U1.P12 (VSS), U1.P14 (VSS), U1.V2 (VREF-), U1.W1 (VSS), U1.W19 (VSS); also elsewhere on the board
unnamed: C13.2, R49.2
unnamed: C27.2, C28.2, C29.2, C31.2, C33.1, C35.1, L3.1, U1.L1 (VDDSMPS), U1.L2 (VDDSMPS), U1.L3 (VDDSMPS), U1.L4 (VDDSMPS), U1.L5 (VDDSMPS)
unnamed: FB1.1, R45.1, R46.1
unnamed: L1.2, R49.1, U1.K1 (VLXSMPS), U1.K2 (VLXSMPS), U1.K3 (VLXSMPS), U1.K4 (VLXSMPS), U1.K5 (VLXSMPS)
unnamed: C12.2, U1.G1 (V08CAP)
unnamed: R47.1, R48.1, U1.N6 (VSSA)
VDD1V8: L2.1, L3.2; also elsewhere on the board
VDD3V3: C14.1, U1.C3 (VDD33USB); also elsewhere on the board
VDDA1V8: C30.2, C32.2, C34.2, C36.2, C37.2, C38.2, C71.2, C72.2, C73.2, C74.2, R45.2, U1.D4 (VDDA18USB), U1.H16 (VDDIO2), U1.J16 (VDDIO2), U1.K16 (VDDIO2), U1.L16 (VDDIO2), U1.M6 (VDDA18PLL), U1.M14 (VDDIO3), U1.M16 (VDDIO3), U1.P6 (VDDA18ADC), U1.V6 (VDDA18CSI); also elsewhere on the board
VDDA1V8PMU: C16.2, L2.2, U1.H1 (VDDA18PMU)
VDDA1V8_AON: C15.2, U1.H6 (VDDA18AON); also elsewhere on the board
VDDCORE: C7.1, C8.1, C9.1, C10.1, C17.2, C18.2, C19.2, C20.2, C21.2, L1.1, U1.G2 (VFBSMPS), U1.P7 (VDDCORE), U1.P9 (VDDCORE), U1.P10 (VDDCORE), U1.P11 (VDDCORE), U1.P13 (VDDCORE), U1.W6 (VDDCSI)
VDDIO: C11.2, C22.2, C23.2, C24.2, C25.2, C26.2, U1.F1 (VBAT), U1.F7 (VDDIO4), U1.F8 (VDDIO4), U1.J14 (VDD), U1.K14 (VDD), U1.L14 (VDD); also elsewhere on the board
VREFP: C5.2, C6.2, FB1.2, U1.W2 (VREF+)

Notes on the sheet:
Analog GND from Leafony I/F
for VDD & VDDIO4
External Reference Input

Parts:
C52: 1uF(M) 50V X5R; C_0402_1005Metric
D5, D6, D7, D8, D9, D10, D11, D12: DF2S7MSL,L3F; SOD-962 SL2_TOS
J3: FH12-22S-0.5SH55; CONN_FH12-22S-0.5SH55_HIR
R64: 0R 1/4W; R_0603_1608Metric
U5, U6, U7: ECMF2-40A100N6; ECMF240A100N6

Connections:
/Camera IF/CSI_CONN_CLK_N: J3.8, U7.2 (D-_TO_CONNECTOR)
/Camera IF/CSI_CONN_CLK_P: J3.9, U7.1 (D+_TO_CONNECTOR)
/Camera IF/CSI_CONN_D0_N: J3.2, U5.2 (D-_TO_CONNECTOR)
/Camera IF/CSI_CONN_D0_P: J3.3, U5.1 (D+_TO_CONNECTOR)
/Camera IF/CSI_CONN_D1_N: J3.5, U6.2 (D-_TO_CONNECTOR)
/Camera IF/CSI_CONN_D1_P: J3.6, U6.1 (D+_TO_CONNECTOR)
CSI_CLK_N: U7.5 (D-_TO_IC); also elsewhere on the board
CSI_CLK_P: U7.6 (D+_TO_IC); also elsewhere on the board
CSI_D0_N: U5.5 (D-_TO_IC); also elsewhere on the board
CSI_D0_P: U5.6 (D+_TO_IC); also elsewhere on the board
CSI_D1_N: U6.5 (D-_TO_IC); also elsewhere on the board
CSI_D1_P: U6.6 (D+_TO_IC); also elsewhere on the board
EN_MODULE: D10.1 (K), J3.18; also elsewhere on the board
GND: C52.2, D5.2 (A), D6.2 (A), D7.2 (A), D8.2 (A), D9.2 (A), D10.2 (A), D11.2 (A), D12.2 (A), J3.1, J3.4, J3.7, J3.10, J3.13, J3.16, J3.19, J3.23 (MP), J3.24 (MP), U5.3 (GND_1), U5.4 (GND_2), U6.3 (GND_1), U6.4 (GND_2), U7.3 (GND_1), U7.4 (GND_2); also elsewhere on the board
I2C1_SCL: D11.1 (K), J3.20; also elsewhere on the board
I2C1_SDA: D12.1 (K), J3.21; also elsewhere on the board
IMU_INT1: D7.1 (K), J3.14; also elsewhere on the board
IMU_INT2: D8.1 (K), J3.15; also elsewhere on the board
NRST_CAM: D9.1 (K), J3.17; also elsewhere on the board
TOF_INT: D6.1 (K), J3.12; also elsewhere on the board
TOF_LPn: D5.1 (K), J3.11; also elsewhere on the board
VDD3V3: R64.1; also elsewhere on the board
VDD_CAM: C52.1, J3.22, R64.2

Parts:
C1, C2: 3.3pF(J) 50V C0G; C_0402_1005Metric
R1, R2: 0R; R_0402_1005Metric
R3, R4, R5: 4.7k(J); R_0402_1005Metric
U1: STM32N657L0H3Q; VFBGA223_10X10_STM
Y1: 32.768kHz; XTAL_NX2012SA-32.768K-STD-MUB-1

Connections:
A0: U1.W12 (PA1); also elsewhere on the board
A1: U1.V8 (PA12); also elsewhere on the board
A2: U1.T8 (PA11); also elsewhere on the board
A3: U1.T9 (PA8); also elsewhere on the board
A4: U1.V9 (PA9); also elsewhere on the board
A5: U1.W9 (PA10); also elsewhere on the board
BOOT1: U1.T10 (PA6); also elsewhere on the board
D1: U1.A15 (PD5); also elsewhere on the board
D2: U1.A10 (PD6); also elsewhere on the board
D3: U1.F11 (PD7); also elsewhere on the board
D4: U1.T13 (PB10); also elsewhere on the board
D5: U1.V13 (PB11); also elsewhere on the board
D6: U1.A8 (PC6); also elsewhere on the board
D7: U1.B8 (PC7); also elsewhere on the board
EN_MODULE: U1.B10 (PD2); also elsewhere on the board
GND: C1.2, C2.2; also elsewhere on the board
I2C1_SDA: R3.1, U1.A7 (PC1); also elsewhere on the board
IMU_INT2: U1.V14 (PB1); also elsewhere on the board
NRST_CAM: U1.F6 (PC8); also elsewhere on the board
unnamed: C1.1, R1.1, Y1.2
unnamed: C2.1, R2.1, Y1.1
unnamed: R1.2, U1.E1 (PC14-OSC32_IN)
unnamed: R2.2, U1.D1 (PC15-OSC32_OUT)
SCL: R5.1, U1.F13 (PD14); also elsewhere on the board
SDA: R4.1, U1.B13 (PD4); also elsewhere on the board
SWCLK: U1.V7 (PA14); also elsewhere on the board
SWDIO: U1.W7 (PA13); also elsewhere on the board
SWO: U1.T14 (PB5); also elsewhere on the board
TEST_N: U1.D11 (PD10); also elsewhere on the board
TOF_INT: U1.A16 (PB13); also elsewhere on the board
VDDIO: R3.2, R4.2, R5.2; also elsewhere on the board

Parts:
R21, R22, R23, R24, R25, R26, R27, R28, R29, R30, R31, R32, R33, R34, R35, R36, R37, R38, R39, R40: 0R; R_0402_1005Metric
R41, R42: 200R(F); R_0402_1005Metric
R43: 10k(J); R_0402_1005Metric; not fitted
R44: 10k(J); R_0402_1005Metric
U1: STM32N657L0H3Q; VFBGA223_10X10_STM

Connections:
CSI_CLK_N: U1.V4 (CSI_CKN); also elsewhere on the board
CSI_CLK_P: U1.W4 (CSI_CKP); also elsewhere on the board
CSI_D0_N: U1.V5 (CSI_D0N); also elsewhere on the board
CSI_D0_P: U1.W5 (CSI_D0P); also elsewhere on the board
CSI_D1_N: U1.V3 (CSI_D1N); also elsewhere on the board
CSI_D1_P: U1.W3 (CSI_D1P); also elsewhere on the board
GND: R41.1, R42.2, R44.1; also elsewhere on the board
HEXASPI_CLK: R24.1; also elsewhere on the board
HEXASPI_DSQ0: R22.1; also elsewhere on the board
HEXASPI_DSQ1: R23.1; also elsewhere on the board
HEXASPI_IO0: R25.1; also elsewhere on the board
HEXASPI_IO1: R26.1; also elsewhere on the board
HEXASPI_IO2: R27.1; also elsewhere on the board
HEXASPI_IO3: R28.1; also elsewhere on the board
HEXASPI_IO4: R29.1; also elsewhere on the board
HEXASPI_IO5: R30.1; also elsewhere on the board
HEXASPI_IO6: R31.1; also elsewhere on the board
HEXASPI_IO7: R32.1; also elsewhere on the board
HEXASPI_IO8: R33.1; also elsewhere on the board
HEXASPI_IO9: R34.1; also elsewhere on the board
HEXASPI_IO10: R35.1; also elsewhere on the board
HEXASPI_IO11: R36.1; also elsewhere on the board
HEXASPI_IO12: R37.1; also elsewhere on the board
HEXASPI_IO13: R38.1; also elsewhere on the board
HEXASPI_IO14: R39.1; also elsewhere on the board
HEXASPI_IO15: R40.1; also elsewhere on the board
HEXASPI_NCS: R21.1; also elsewhere on the board
NRST: U1.F2 (NRST); also elsewhere on the board
unnamed: R43.2, R44.2, U1.F4 (BOOT0)
unnamed: R42.1, U1.T6 (CSI_REXT)
unnamed: R41.2, U1.A2 (OTG1_TXRTUNE)
unnamed: R21.2, U1.F16 (PO0)
unnamed: R22.2, U1.G18 (PO2)
unnamed: R23.2, U1.E18 (PO3)
unnamed: R24.2, U1.J18 (PO4)
unnamed: R25.2, U1.H18 (PP0)
unnamed: R26.2, U1.F18 (PP1)
unnamed: R27.2, U1.K18 (PP2)
unnamed: R28.2, U1.K19 (PP3)
unnamed: R29.2, U1.L19 (PP4)
unnamed: R30.2, U1.J19 (PP5)
unnamed: R31.2, U1.H19 (PP6)
unnamed: R32.2, U1.G19 (PP7)
unnamed: R33.2, U1.F19 (PP8)
unnamed: R34.2, U1.E19 (PP9)
unnamed: R35.2, U1.D18 (PP10)
unnamed: R36.2, U1.N19 (PP11)
unnamed: R37.2, U1.N18 (PP12)
unnamed: R38.2, U1.M19 (PP13)
unnamed: R39.2, U1.M18 (PP14)
unnamed: R40.2, U1.L18 (PP15)
PWR_ON: U1.G4 (PWR_ON); also elsewhere on the board
USB1_HS_N: U1.B3 (OTG1_HSDM); also elsewhere on the board
USB1_HS_P: U1.A3 (OTG1_HSDP); also elsewhere on the board
VDDA1V8_AON: U1.A1 (PDR_ON); also elsewhere on the board
VDDIO: R43.1; also elsewhere on the board

Parts:
CN1: Leafony Bus; CN_F29

Connections:
+3V3: CN1.F1 (3.3V); also elsewhere on the board
+5V: CN1.F3 (VBUS); also elsewhere on the board
A0: CN1.F6 (A0); also elsewhere on the board
A1: CN1.F8 (A1); also elsewhere on the board
A2: CN1.F10 (A2); also elsewhere on the board
A3: CN1.F12 (A3); also elsewhere on the board
A4: CN1.F14 (A4); also elsewhere on the board
A5: CN1.F16 (A5); also elsewhere on the board
AREF: CN1.F4 (AREF); also elsewhere on the board
D0: CN1.F18 (D0); also elsewhere on the board
D1: CN1.F20 (D1); also elsewhere on the board
D2: CN1.F22 (D2); also elsewhere on the board
D3: CN1.F24 (D3); also elsewhere on the board
D4: CN1.F26 (D4); also elsewhere on the board
D5: CN1.F28 (D5); also elsewhere on the board
D6: CN1.F7 (D6); also elsewhere on the board
D7: CN1.F9 (D7); also elsewhere on the board
D8: CN1.F11 (D8); also elsewhere on the board
D9: CN1.F13 (D9); also elsewhere on the board
D10: CN1.F15 (D10); also elsewhere on the board
D11: CN1.F17 (D11); also elsewhere on the board
D12: CN1.F19 (D12); also elsewhere on the board
D13: CN1.F21 (D13); also elsewhere on the board
GND: CN1.F27 (GND); also elsewhere on the board
NRST: CN1.F5 (RESET); also elsewhere on the board
SCL: CN1.F25 (SCL); also elsewhere on the board
SDA: CN1.F23 (SDA); also elsewhere on the board
SWCLK: CN1.F29 (SWCLK); also elsewhere on the board
SWDIO: CN1.F2 (SWDIO); also elsewhere on the board

Notes on the sheet:
Leafonyリーフは上方向にのみ積み重ねること

Schematic: stm32_pe_pn.kicad_sch, Leafony STM32N6

Parts:
C3, C4: 8.2pF(J) 50V C0G; C_0402_1005Metric
D1: SML-A12U8TT86; LED_SML-A12_ROM
R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18: 0R; R_0402_1005Metric
R19: 1k(J); R_0402_1005Metric
R20: 4.7k(J); R_0402_1005Metric
U1: STM32N657L0H3Q; VFBGA223_10X10_STM
Y2: 48MHz; CS13734-48M

Connections:
D0: U1.M4 (PF6); also elsewhere on the board
D8: U1.U3 (PF0); also elsewhere on the board
D9_MCU: U1.U1 (PF1); also elsewhere on the board
D10: U1.D8 (PE11); also elsewhere on the board
D11: U1.F9 (PE14); also elsewhere on the board
D12: U1.A9 (PE13); also elsewhere on the board
D13: U1.D10 (PE12); also elsewhere on the board
GND: C3.2, C4.2, Y2.2, Y2.4; also elsewhere on the board
I2C1_SCL: R20.1, U1.B7 (PH9); also elsewhere on the board
IMU_INT1: U1.V11 (PG12); also elsewhere on the board
unnamed: C3.1, R17.1, Y2.3
unnamed: C4.1, R18.1, Y2.1
unnamed: D1.1 (K), R19.2
unnamed: R19.1, U1.T12 (PG10)
unnamed: R17.2, U1.A5 (PH0-OSC_IN)
unnamed: R18.2, U1.B5 (PH1-OSC_OUT)
unnamed: R6.2, U1.R19 (PN0)
unnamed: R7.2, U1.P16 (PN1)
unnamed: R8.2, U1.T19 (PN2)
unnamed: R9.2, U1.P19 (PN3)
unnamed: R10.2, U1.V19 (PN4)
unnamed: R11.2, U1.U18 (PN5)
unnamed: R12.2, U1.U19 (PN6)
unnamed: R13.2, U1.V18 (PN8)
unnamed: R14.2, U1.T18 (PN9)
unnamed: R15.2, U1.R18 (PN10)
unnamed: R16.2, U1.P18 (PN11)
OCTOSPI_CLK: R12.1; also elsewhere on the board
OCTOSPI_DSQ: R6.1; also elsewhere on the board
OCTOSPI_IO0: R8.1; also elsewhere on the board
OCTOSPI_IO1: R9.1; also elsewhere on the board
OCTOSPI_IO2: R10.1; also elsewhere on the board
OCTOSPI_IO3: R11.1; also elsewhere on the board
OCTOSPI_IO4: R13.1; also elsewhere on the board
OCTOSPI_IO5: R14.1; also elsewhere on the board
OCTOSPI_IO6: R15.1; also elsewhere on the board
OCTOSPI_IO7: R16.1; also elsewhere on the board
OCTOSPI_NCS: R7.1; also elsewhere on the board
TOF_LPn: U1.V16 (PG9); also elsewhere on the board
VCP_RX: U1.B9 (PE6); also elsewhere on the board
VCP_TX: U1.D9 (PE5); also elsewhere on the board
VDDIO: D1.2 (A), R20.2; also elsewhere on the board

Schematic: usb.kicad_sch, Leafony STM32N6

Parts:
C53: 10nF(M) 50V X7R; C_0402_1005Metric
C54: 100nF(M) 16V X7R; C_0201_0603Metric
C55: 1uF(M) 50V X5R; C_0402_1005Metric
D13: BAT30F4; CR_B30F4_STM
J4: CX90M-16P; HRS_CX90M-16P; PARTREV 2
Q2: STL6N3LLH6; POWERFLAT-2X2
R65, R66: 5.1k(J); R_0402_1005Metric; not fitted
R67: 10k(F); R_0402_1005Metric
R68: 2.7k(F); R_0402_1005Metric
R69: 0R 1/4W; R_0603_1608Metric
TP1: TestPoint; TestPoint_Pad_D1.0mm
U8: ECMF2-40A100N6; ECMF240A100N6
U9: TCPP01-M12; QFN50P300X300X100-13N-D
U10: MAX40200ANS; WLP-4_0.728x0.728mm_Layout2x2_P0.35mm

Connections:
+5V: R69.2, TP1.1; also elsewhere on the board
/USB-C/CC1c: J4.A5 (CC1), R65.2, U9.7 (CC1C)
/USB-C/CC2c: J4.B5 (CC2), R66.2, U9.9 (CC2C)
/USB-C/DMc: J4.A7 (DA-), J4.B7 (DB-), U8.2 (D-_TO_CONNECTOR)
/USB-C/DPc: J4.A6 (DA+), J4.B6 (DB+), U8.1 (D+_TO_CONNECTOR)
/USB-C/VBUS: C55.1, Q2.4 (S_1), Q2.8 (S_2), U9.4 (SOURCE), U10.A1 (VDD), U10.B1 (EN)
/USB-C/VBUSc: C53.2, D13.2 (A), J4.A4 (VBUSA1), J4.A9 (VBUSA2), J4.B4 (VBUSB1), J4.B9 (VBUSB2), Q2.1 (D_1), Q2.2 (D_2), Q2.5 (D_3), Q2.6 (D_4), Q2.7 (D_5), R67.2
GND: C53.1, C54.2, C55.2, J4.A1 (GNDA1), J4.A12 (GNDA2), J4.B1 (GNDB1), J4.B12 (GNDB2), J4.MID1 (MID), J4.MID2 (MID__1), J4.S1 (SHIELD), J4.S2 (SHIELD__1), J4.S3 (SHIELD__2), J4.S4 (SHIELD__3), R65.1, R66.1, R68.1, U8.3 (GND_1), U8.4 (GND_2), U9.1 (CC2), U9.2 (GND), U9.3 (CC1), U9.10 (DB/), U9.11 (FLT/), U9.12 (VCC), U9.13 (EP), U10.B2 (GND); also elsewhere on the board
unnamed: C54.1, D13.1 (K), U9.8 (IN_GD)
unnamed: Q2.3 (G), U9.5 (GATE)
unnamed: R67.1, R68.2, U9.6 (VBUS_CTRL)
unnamed: R69.1, U10.A2 (OUT)
USB1_HS_N: U8.5 (D-_TO_IC); also elsewhere on the board
USB1_HS_P: U8.6 (D+_TO_IC); also elsewhere on the board
